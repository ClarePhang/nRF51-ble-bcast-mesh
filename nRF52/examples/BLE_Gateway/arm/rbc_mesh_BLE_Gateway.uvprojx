# Keil uVision project rbc_mesh_BLE_Gateway.uvprojx, settings and files
target nRF52832 xxAA (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rbc_gateway_example +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10040 NRF52 BLE_STACK_SUPPORT_REQD S132 SOFTDEVICE_PRESENT DEBUG
  c misc: --c99
  c include: ..\include;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\SDK\bsp;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\drivers_nrf\config
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20004300 size 0xbd00
  link misc: --callgraph
  group app
    ../: main.c nrf_adv_conn.c led_config.c
  group rbc_mesh
    ../../../rbc_mesh/src/: radio_control.c rbc_mesh.c timer_control.c timeslot_handler.c trickle.c mesh_gatt.c transport_control.c mesh_aci.c serial_handler_uart.c fifo.c event_handler.c version_handler.c mesh_packet.c bootloader_util.c bootloader_app.c rand.c bootloader_info_app.c handle_storage.c
  group core
    ./: system_nrf52.c arm_startup_nrf52.s
  group lib
    ../../../../../../components/ble/common/: ble_advdata.c
    ../../../../../../components/drivers_nrf/spi_slave/: spi_slave.c
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
